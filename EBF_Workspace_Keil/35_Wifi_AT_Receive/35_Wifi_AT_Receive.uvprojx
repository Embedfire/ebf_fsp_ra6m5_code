# Keil uVision project 35_Wifi_AT_Receive.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.1.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: 35_Wifi_AT_Receive
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.1.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\debug_uart;.\src\debug_wifi;.\src\led
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/debug_uart/: bsp_debug_uart.c bsp_debug_uart.h
    ./src/debug_wifi/: bsp_debug_wifi.c bsp_debug_wifi.h
    ./src/led/: bsp_led.c bsp_led.h
software components: Flex Software:RA Configuration 1.0.0
