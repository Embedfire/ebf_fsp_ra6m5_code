# Keil uVision project EBF_RA6M5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.4.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: EBF_RA6M5
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.0.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src;.\src\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group FatFs
    ./FatFs/ff15/: diskio.c diskio.h ff.c ff.h ffconf.h ffunicode.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/led/: bsp_led.c bsp_led.h
    ./src/debug_uart/: bsp_debug_uart.c bsp_debug_uart.h
    ./src/sdhi_sdcard/: bsp_sdhi_sdcard.c bsp_sdhi_sdcard.h
software components: Flex Software:RA Configuration 1.0.0
