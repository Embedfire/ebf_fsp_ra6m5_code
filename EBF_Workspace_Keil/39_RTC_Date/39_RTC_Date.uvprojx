# Keil uVision project 39_RTC_Date.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: 39_RTC_Date
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.1.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\debug_uart;.\src\bsp_dtc;.\src\led
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Source Group 1
    ./src/debug_uart/: bsp_debug_uart.c
    ./src/bsp_dtc/: bsp_dtc.c
    ./src/led/: bsp_led.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/bsp_dtc/: bsp_dtc.c bsp_dtc.h
    ./src/debug_uart/: bsp_debug_uart.c bsp_debug_uart.h
    ./src/led/: bsp_led.c bsp_led.h
software components: Flex Software:RA Configuration 1.0.0
