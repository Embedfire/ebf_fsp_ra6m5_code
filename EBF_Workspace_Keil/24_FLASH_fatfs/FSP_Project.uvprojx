# Keil uVision project FSP_Project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: R7FA6M5BH3CFC Renesas
  pack: Renesas.RA_DFP.4.0.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FSP_Project
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.0.0-beta.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\user;.\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group fatfs
    ./FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group user
    ./user/: bsp_qspi_flash.c bsp_sdhi.c bsp_debug_uart.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
